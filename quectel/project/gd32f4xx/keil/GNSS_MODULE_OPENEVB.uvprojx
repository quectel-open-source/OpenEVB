# Keil uVision project GNSS_MODULE_OPENEVB.uvprojx, settings and files
target OPENEVB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x0B0000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GNSS_MODULE_OPENEVB
  AfterMake: fromelf --bin !L --output GNSS_MODULE_OPENEVB.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,NDEBUG,__EXAMPLE_GNSS__
  c misc: --diag_suppress=513,167,2803
  c include: ..\..\..\..\plat\gd32f4xx\CMSIS;..\..\..\..\plat\gd32f4xx\CMSIS\GD\GD32F4xx\Include;..\..\..\..\plat\gd32f4xx\CMSIS\GD\GD32F4xx\Source\ARM;..\..\..\..\plat\gd32f4xx\GD32F4xx_standard_peripheral\Include;..\..\..\..\os\FreeRTOS\FreeRTOS-Kernel\include;..\..\..\..\os\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F;..\..\..\..\os\FreeRTOS\FreeRTOS-Plus-CLI;..\..\..\..\os\FreeRTOS\FreeRTOS-Cellular-Interface\source\include;..\..\..\..\os\FreeRTOS\FreeRTOS-Cellular-Interface\source\include\common;..\..\..\..\os\FreeRTOS\FreeRTOS-Cellular-Interface\source\include\private;..\..\..\..\os\FreeRTOS\FreeRTOS-Cellular-Interface\source\interface;..\..\..\..\os\FreeRTOS\coreHTTP\source\dependency\3rdparty\http_parser;..\..\..\..\os\FreeRTOS\coreHTTP\source\include;..\..\..\..\os\FreeRTOS\coreHTTP\source\interface;..\..\..\..\os\FreeRTOS\backoff_algorithm\source\include;..\..\..\..\third_party\cJSON;..\..\..\..\third_party\mbedtls\configs;..\..\..\..\third_party\mbedtls\include;..\..\..\..\third_party\mbedtls\include\mbedtls;..\..\..\..\third_party\mbedtls\include\psa;..\..\..\..\third_party\mbedtls\library;..\..\..\app;..\..\..\app\config;..\..\..\bsp\gd32f4xx\driver;..\..\..\component;..\..\..\component\ql_cellular_wrapper;..\..\..\component\ql_cjson;..\..\..\component\ql_common;..\..\..\component\ql_log;..\..\..\component\ql_network_transport\http_utils;..\..\..\component\ql_network_transport\mbedtls_freertos;..\..\..\component\ql_network_transport\sockets_wrapper\cellular;..\..\..\component\ql_network_transport\using_mbedtls;..\..\..\component\ql_network_transport\using_plaintext;..\..\..\component\ql_nmea;..\..\..\component\ql_gnss;..\..\..\hal;..\..\..\example\inc;..\..\..\component\ql_ff;..\..\..\..\third_party\ff15\source;..\..\..\component\quecrtk
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x200000
  memory RVCT9: RAM 0x20000004 size 0xafffc
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../../../plat/gd32f4xx/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group CMSIS
    ../../../../plat/gd32f4xx/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_standard_peripheral
    ../../../../plat/gd32f4xx/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group FreeRTOS-Kernel
    ../../../../os/FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../../../../os/FreeRTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
    ../../../../os/FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS-Cellular-Interface
    ../../../../os/FreeRTOS/FreeRTOS-Cellular-Interface/source/: cellular_3gpp_api.c cellular_3gpp_urc_handler.c cellular_at_core.c cellular_common.c cellular_common_api.c cellular_pkthandler.c cellular_pktio.c
  group coreHTTP
    ../../../../os/FreeRTOS/coreHTTP/source/dependency/3rdparty/http_parser/: http_parser.c
    ../../../../os/FreeRTOS/coreHTTP/source/: core_http_client.c
  group backoff_algorithm
    ../../../../os/FreeRTOS/backoff_algorithm/source/: backoff_algorithm.c
  group mbedtls
    ../../../../third_party/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group cJSON
    ../../../../third_party/cJSON/: cJSON.c cJSON_Utils.c
  group ff15
    ../../../../third_party/ff15/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group config
    ../../../app/config/: cellular_config.h core_http_config.h FreeRTOSConfig.h mbedtls_config.h
  group quectel/app
    ../../../app/: gd32f4xx_it.c main.c ql_application.c ql_version.c
  group quectel/bsp
    ../../../bsp/gd32f4xx/driver/: ql_clock.c ql_delay.c ql_flash.c ql_rtc.c ql_sdcard.c ql_time.c ql_trng.c ql_uart.c ql_iic.c ql_spi.c
  group quectel/component
    ../../../component/ql_cjson/: ql_cjson_object.c
    ../../../component/ql_common/: ql_check.c ql_ctype.c ql_utils.c
    ../../../component/ql_log/: ql_log.c
    ../../../component/ql_network_transport/http_utils/: ql_http_utils.c
    ../../../component/ql_network_transport/mbedtls_freertos/: mbedtls_bio_freertos_cellular.c mbedtls_freertos_port.c
    ../../../component/ql_network_transport/sockets_wrapper/cellular/: sockets_wrapper.c
    ../../../component/ql_network_transport/using_mbedtls/: using_mbedtls.c
    ../../../component/ql_network_transport/using_plaintext/: using_plaintext.c
    ../../../component/ql_nmea/: ql_nmea.c
    ../../../component/ql_cellular_wrapper/: cellular_platform.c cellular_setup.c cellular_wrapper.c cellular_wrapper_api.c cellular_wrapper_common.c cellular_wrapper_urc_handler.c
    ../../../component/ql_ff/: ql_ff_user.c
    ../../../component/quecrtk/: test_ca.c libqntrip.lib
  group quectel/hal
    ../../../hal/: ql_cellular_dev.c ql_uart_cellular.c
  group quectel/example
    ../../../example/src/: example_ntrip_client.c example_lcx9h_iic_fwdl.c example_lcx9h_iic_nmea.c example_lg69tap_iic_nmea.c example_nmea_parse.c example_nmea_save.c example_lcx9h_iic_fwupg.c example_quecrtk.c example_lcx6g_iic_fwupg.c example_lcx9h_spi_nmea.c
